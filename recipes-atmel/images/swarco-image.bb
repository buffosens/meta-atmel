DESCRIPTION = "A test image preparing our swarco linux v4"
LICENSE = "MIT"
PR = "r1"

require swarco-image.inc

